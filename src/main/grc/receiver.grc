options:
  parameters:
    author: Defective4
    generate_options: no_gui
    id: receiver
    output_language: python
    run_options: run
    title: Pi Radio Receiver
  states: {}

blocks:
- name: aprs
  id: variable
  parameters:
    comment: adjustable
    value: '0'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: adjustable
    value: 87e6
  states: {}
- name: decimation_1
  id: variable
  parameters:
    value: '5'
  states: {}
- name: decimation_2
  id: variable
  parameters:
    value: '10'
  states: {}
- name: deemp
  id: variable
  parameters:
    comment: adjustable
    value: '0.00005'
  states: {}
- name: demod
  id: variable
  parameters:
    comment: |-
      adjustable
      0 = AM
      1 = FM
      2 = NFM
    value: '0'
  states: {}
- name: demod_freq
  id: variable
  parameters:
    comment: adjustable
    value: '0'
  states: {}
- name: enable_rds
  id: variable
  parameters:
    comment: adjustable
    value: '0'
  states: {}
- name: fm_stereo
  id: variable
  parameters:
    comment: adjustable
    value: '0'
  states: {}
- name: gain
  id: variable
  parameters:
    comment: adjustable
    value: '0'
  states: {}
- name: muted
  id: variable
  parameters:
    comment: adjustable
    value: '0'
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '1.0'
    gain: '1.0'
    ntaps: '151'
    samp_rate: '19000'
    sym_rate: 19000/8
  states: {}
- name: rrc_taps_manchester
  id: variable
  parameters:
    value: '[rrc_taps[n] - rrc_taps[n+8] for n in range(len(rrc_taps)-8)]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '53'
    max_gain: '1000'
    rate: '2e-3'
    reference: '0.585'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: 6e3
    audio_stop: 8e3
    chan_rate: samp_rate/decimation_1/decimation_2
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate/decimation_1/decimation_2
    tau: deemp
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '48000'
    tau: deemp
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: '-654e-4'
    min_freq: '654e-4'
    w: '5e-2'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate / decimation_1) / (2*math.pi*75000)
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: decimation_2
    quad_rate: samp_rate/decimation_1
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: decimation_2
    deemph_tau: deemp
    quad_rate: samp_rate/decimation_1
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: |-
      NOTE:
      Only WBFM Receive PLL
      outputs true stereo
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/defective/rec.cfile
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '3e-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '5e-1'
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: enable_rds == 1 and muted == 0
    input_index: '0'
    num_inputs: '1'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: 1 if fm_stereo == 1 else 0
    type: complex
  states: {}
- name: blocks_selector_0_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: 0 if demod == 0 or demod == 2 else 1
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: muted == 0
    input_index: 2 if demod == 0 else 3 if demod == 2 else 1 if fm_stereo == 1 else 0
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_1_0
  id: blocks_selector
  parameters:
    enabled: muted == 0
    input_index: 2 if demod == 0 else 3 if demod == 2 else 1 if fm_stereo == 1 else 0
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: 0 if demod == 0 else 1
    type: complex
  states: {}
- name: blocks_selector_3
  id: blocks_selector
  parameters:
    enabled: aprs == 1
    input_index: '0'
    num_inputs: '1'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: cmd_addr
  id: parameter
  parameters:
    label: Command server address
    short_id: a
    type: str
    value: tcp://localhost:55555
  states: {}
- name: dev_args
  id: parameter
  parameters:
    label: Device arguments
    short_id: s
    type: str
    value: '""'
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: digital.constellation_bpsk().base()
    fmax: '0.002'
    fmin: '-0.002'
    loop_bw: 2*math.pi / 100
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '16'
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Message to Command',
                  in_sig=None,
                  out_sig=None
              )

              self.message_port_register_in(pmt.intern("inpair"))
              self.set_msg_handler(pmt.intern("inpair"), self.msg_handler)

          def init_callbacks(self, demod, demod_freq, enable_rds, fm_stereo, deemp, gain, center_freq, aprs, muted):
              self.callbacks = {
                  "demod": demod,
                  "demod_freq": demod_freq,
                  "enable_rds": enable_rds,
                  "fm_stereo": fm_stereo,
                  "deemp": deemp,
                  "gain": gain,
                  "center_freq": center_freq,
                  "aprs": aprs,
                  "muted": muted
              }

          def msg_handler(self, msg):
              if not pmt.is_pair(msg) or pmt.is_dict(msg) or pmt.is_pdu(msg):
                  gr.log.warn(
                      "Input message %s is not a simple pair, dropping" % repr(msg))
                  return

              val = pmt.to_python(pmt.cdr(msg))
              key = pmt.to_python(pmt.car(msg))
              if key in self.callbacks:
                  self.callbacks[key](val)

          def stop(self):
              return True
    comment: |-
      Handle commands
      received from the controller
  states: {}
- name: fir_filter_xxx_2
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_taps_manchester
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: demod_freq
    decim: decimation_1
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation_1), samp_rate/(2*decimation_1), 150e3)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 57e3
    decim: '19'
    samp_rate: samp_rate / decimation_1
    taps: firdes.low_pass(1.0, samp_rate / 19, 7.5e3, 5e3)
    type: fcc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 6e3
    decim: decimation_2
    gain: '1'
    samp_rate: samp_rate/decimation_1
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: 127.0.0.1
    mode: '1'
    port: resampler_server
    type: float
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: rtl_args
    bb_gain0: '20'
    dc_offset_mode0: '1'
    freq0: center_freq
    gain0: float(gain)
    gain_mode0: 'False'
    if_gain0: '0'
    iq_balance_mode0: '1'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate // decimation_1 // 19
    interp: '19000'
    type: ccc
  states: {}
- name: rds_addr
  id: parameter
  parameters:
    label: RDS server address
    short_id: r
    type: str
    value: tcp://localhost:55556
  states: {}
- name: rds_decoder_0
  id: rds_decoder
  parameters: {}
  states: {}
- name: rds_parser_0
  id: rds_parser
  parameters:
    pty_locale: '0'
  states: {}
- name: resampler_server
  id: parameter
  parameters:
    label: APRS Resampler Server Port
    short_id: p
    type: intx
    value: '55557'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: self.epy_block_0.init_callbacks(self.set_demod, self.set_demod_freq, self.set_enable_rds, self.set_fm_stereo, self.set_deemp, self.set_gain, self.set_center_freq, self.set_aprs, self.set_muted)
    comment: Initialize command callbacks
    section: main_after_init
  states: {}
- name: snippet_1
  id: snippet
  parameters:
    code: print("RECV READY", file=sys.stderr);
    section: main_after_start
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: cmd_addr
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: rds_addr
    bind: 'False'
    timeout: '100'
  states: {}

connections:
- [analog_agc3_xx_0, '0', analog_pll_carriertracking_cc_0, '0']
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_am_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_fm_deemph_0, '0', blocks_selector_1, '0']
- [analog_fm_deemph_0, '0', blocks_selector_1_0, '0']
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_pll_carriertracking_cc_0, '0', analog_am_demod_cf_0, '0']
- [analog_quadrature_demod_cf_0, '0', freq_xlating_fir_filter_xxx_1_0, '0']
- [analog_wfm_rcv_0, '0', analog_fm_deemph_0, '0']
- [analog_wfm_rcv_pll_0, '0', blocks_selector_1, '1']
- [analog_wfm_rcv_pll_0, '1', blocks_selector_1_0, '1']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_selector_1, '2']
- [blocks_multiply_const_vxx_0, '0', blocks_selector_1_0, '2']
- [blocks_multiply_const_vxx_0_0, '0', blocks_selector_1, '3']
- [blocks_multiply_const_vxx_0_0, '0', blocks_selector_1_0, '3']
- [blocks_selector_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_selector_0_0, '0', analog_wfm_rcv_0, '0']
- [blocks_selector_0_0, '1', analog_wfm_rcv_pll_0, '0']
- [blocks_selector_0_0_0, '0', low_pass_filter_0, '0']
- [blocks_selector_0_0_0, '1', blocks_selector_0, '0']
- [blocks_selector_0_0_0, '1', blocks_selector_0_0, '0']
- [blocks_selector_1, '0', audio_sink_0, '0']
- [blocks_selector_1_0, '0', audio_sink_0, '1']
- [blocks_selector_1_0, '0', blocks_selector_3, '0']
- [blocks_selector_2, '0', analog_agc3_xx_0, '0']
- [blocks_selector_2, '1', analog_nbfm_rx_0, '0']
- [blocks_selector_3, '0', network_tcp_sink_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [digital_constellation_receiver_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', rds_decoder_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [fir_filter_xxx_2, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_selector_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_1_0, '0', rational_resampler_xxx_1, '0']
- [low_pass_filter_0, '0', blocks_selector_2, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rational_resampler_xxx_1, '0', fir_filter_xxx_2, '0']
- [rds_decoder_0, out, rds_parser_0, in]
- [rds_parser_0, out, zeromq_push_msg_sink_0, in]
- [zeromq_pull_msg_source_0, out, epy_block_0, inpair]

metadata:
  file_format: 1
  grc_version: 3.10.5.1
